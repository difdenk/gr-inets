<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>directional_sending</value></param>
<param><key>author</key><value>Can Ercandogu</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Directional Sending</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>ack_frame_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>ack_frame_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>ampdu_frame_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>ampdu_frame_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>amsdu_frame_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>amsdu_frame_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>beacon_frame_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>beacon_frame_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>block_id</value></param>
<param><key>label</key><value>block_id</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.6</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>constellation.bits_per_symbol()</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>sps</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_frequency</value></param>
<param><key>label</key><value>center_frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3.76e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>constellation</value></param>
<param><key>label</key><value>Constellation</value></param>
<param><key>value</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>cts_frame_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>cts_frame_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>data_frame_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>data_frame_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>develop_mode</value></param>
<param><key>label</key><value>develop mode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>digital_burst_shaper_xx</key>
<param><key>id</key><value>digital_burst_shaper_xx_0</value></param>
<param><key>insert_phasing</key><value>False</value></param>
<param><key>length_tag_name</key><value>"packet_len"</value></param>
<param><key>post_padding</key><value>0</value></param>
<param><key>pre_padding</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>window</key><value>gnuradio.fft.window.hanning(1024)</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>constellation.points()</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>direction_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>direction_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_name_extension_pending</value></param>
<param><key>label</key><value>file name extension pending</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"t1Fr"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_name_extension_t_control</value></param>
<param><key>label</key><value>file name extension control</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"t1TXs"</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>inets_decouple_frame_info</key>
<param><key>id</key><value>inets_decouple_frame_info_0</value></param>
<param><key>block_id</key><value>block_id</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_direction_mapper</key>
<param><key>id</key><value>inets_direction_mapper_0</value></param>
<param><key>block_id</key><value>75</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>phase_1</key><value>phase</value></param>
<param><key>phase_2</key><value>phase</value></param>
<param><key>phase_3</key><value>phase</value></param>
<param><key>phase_4</key><value>phase</value></param>
</block>
<block>
<key>inets_message_tomb</key>
<param><key>id</key><value>inets_message_tomb_0</value></param>
</block>
<block>
<key>inets_packetizer</key>
<param><key>id</key><value>inets_packetizer_0</value></param>
<param><key>bps</key><value>constellation.bits_per_symbol() * (samp_rate / sps)</value></param>
<param><key>block_id</key><value>32</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>padding</key><value>64</value></param>
<param><key>preamble</key><value>preamble</value></param>
</block>
<block>
<key>inets_pending_tx_finish</key>
<param><key>id</key><value>inets_pending_tx_finish_0</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>file_name_extension</key><value>file_name_extension_pending</value></param>
<param><key>interframe_interval_s</key><value>interframe_interval_s</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>name_with_timestamp</key><value>name_with_timestamp</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0</value></param>
<param><key>start_next_time_s</key><value>5</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>inets_t_control_tx_cc</key>
<param><key>id</key><value>inets_t_control_tx_cc_0</value></param>
<param><key>block_id</key><value>4</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>directional_mode</key><value>1</value></param>
<param><key>file_name_extension</key><value>file_name_extension_t_control</value></param>
<param><key>frequency</key><value>center_frequency</value></param>
<param><key>record_on</key><value>record_on</value></param>
<param><key>t_pretx_interval_s</key><value>0</value></param>
<param><key>sweep_mode</key><value>sweep_mode</value></param>
<param><key>antenna_number</key><value>1</value></param>
<param><key>bps</key><value>constellation.bits_per_symbol() * (samp_rate / sps)</value></param>
<param><key>name_with_timestamp</key><value>name_with_timestamp</value></param>
</block>
<block>
<key>inets_t_control_tx_cc</key>
<param><key>id</key><value>inets_t_control_tx_cc_0_0</value></param>
<param><key>block_id</key><value>4</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>directional_mode</key><value>1</value></param>
<param><key>file_name_extension</key><value>file_name_extension_t_control</value></param>
<param><key>frequency</key><value>center_frequency</value></param>
<param><key>record_on</key><value>record_on</value></param>
<param><key>t_pretx_interval_s</key><value>0</value></param>
<param><key>sweep_mode</key><value>sweep_mode</value></param>
<param><key>antenna_number</key><value>4</value></param>
<param><key>bps</key><value>constellation.bits_per_symbol() * (samp_rate / sps)</value></param>
<param><key>name_with_timestamp</key><value>name_with_timestamp</value></param>
</block>
<block>
<key>inets_t_control_tx_cc</key>
<param><key>id</key><value>inets_t_control_tx_cc_0_1</value></param>
<param><key>block_id</key><value>4</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>directional_mode</key><value>1</value></param>
<param><key>file_name_extension</key><value>file_name_extension_t_control</value></param>
<param><key>frequency</key><value>center_frequency</value></param>
<param><key>record_on</key><value>record_on</value></param>
<param><key>t_pretx_interval_s</key><value>0</value></param>
<param><key>sweep_mode</key><value>sweep_mode</value></param>
<param><key>antenna_number</key><value>3</value></param>
<param><key>bps</key><value>constellation.bits_per_symbol() * (samp_rate / sps)</value></param>
<param><key>name_with_timestamp</key><value>name_with_timestamp</value></param>
</block>
<block>
<key>inets_t_control_tx_cc</key>
<param><key>id</key><value>inets_t_control_tx_cc_0_2</value></param>
<param><key>block_id</key><value>4</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>directional_mode</key><value>1</value></param>
<param><key>file_name_extension</key><value>file_name_extension_t_control</value></param>
<param><key>frequency</key><value>center_frequency</value></param>
<param><key>record_on</key><value>record_on</value></param>
<param><key>t_pretx_interval_s</key><value>0</value></param>
<param><key>sweep_mode</key><value>sweep_mode</value></param>
<param><key>antenna_number</key><value>2</value></param>
<param><key>bps</key><value>constellation.bits_per_symbol() * (samp_rate / sps)</value></param>
<param><key>name_with_timestamp</key><value>name_with_timestamp</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interframe_interval_s</value></param>
<param><key>label</key><value>interframe_interval_s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>name_with_timestamp</value></param>
<param><key>label</key><value>name with timestamp</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>reconfig_in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_1</value></param>
<param><key>label</key><value>direction_in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_1_0</value></param>
<param><key>label</key><value>movement_tracker_in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phase</value></param>
<param><key>label</key><value>phase</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble</value></param>
<param><key>label</key><value>preamble</value></param>
<param><key>value</key><value>[]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>record_on</value></param>
<param><key>label</key><value>record on</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.8</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>rts_frame_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>rts_frame_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>rx_control_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>rx_control_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Samplerate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>sweep_finished</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>sweep_finished</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sweep_mode</value></param>
<param><key>label</key><value>sweep_mode</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>label</key><value>system time granularity us</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>t_pretx_interval_s</value></param>
<param><key>label</key><value>t_pretx_interval_s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>label</key><value>tx_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>center_frequency</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>center_frequency</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>tx_gain</value></param>
<param><key>ant2</key><value>TX/RX</value></param>
<param><key>center_freq2</key><value>center_frequency</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>tx_gain</value></param>
<param><key>ant3</key><value>TX/RX</value></param>
<param><key>center_freq3</key><value>center_frequency</value></param>
<param><key>norm_gain3</key><value>False</value></param>
<param><key>gain3</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.10.2, addr1=192.168.10.3"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>A:0 B:0</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>clock_source1</key><value>external</value></param>
<param><key>sd_spec1</key><value>A:0 B:0</value></param>
<param><key>time_source1</key><value>external</value></param>
<param><key>nchan</key><value>4</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>len_tag_name</key><value>packet_len</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>unknown_frame_out</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>unknown_frame_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>label</key><value>USRP device address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"addr0=192.168.10.2, addr1=192.168.10.3"</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_burst_shaper_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>inets_t_control_tx_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>inets_t_control_tx_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>inets_t_control_tx_cc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>inets_t_control_tx_cc_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_decouple_frame_info_0</source_block_id><sink_block_id>inets_message_tomb_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_decouple_frame_info_0</source_block_id><sink_block_id>inets_packetizer_0</sink_block_id><source_key>frame_pmt_out</source_key><sink_key>payload_in</sink_key></connection>
<connection><source_block_id>inets_direction_mapper_0</source_block_id><sink_block_id>inets_t_control_tx_cc_0</sink_block_id><source_key>phase_out</source_key><sink_key>phase_in</sink_key></connection>
<connection><source_block_id>inets_direction_mapper_0</source_block_id><sink_block_id>inets_t_control_tx_cc_0_0</sink_block_id><source_key>phase_out</source_key><sink_key>phase_in</sink_key></connection>
<connection><source_block_id>inets_direction_mapper_0</source_block_id><sink_block_id>inets_t_control_tx_cc_0_1</sink_block_id><source_key>phase_out</source_key><sink_key>phase_in</sink_key></connection>
<connection><source_block_id>inets_direction_mapper_0</source_block_id><sink_block_id>inets_t_control_tx_cc_0_2</sink_block_id><source_key>phase_out</source_key><sink_key>phase_in</sink_key></connection>
<connection><source_block_id>inets_packetizer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>packet_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>inets_pending_tx_finish_0</source_block_id><sink_block_id>ack_frame_out</sink_block_id><source_key>ack_frame_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_pending_tx_finish_0</source_block_id><sink_block_id>ampdu_frame_out</sink_block_id><source_key>ampdu_frame_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_pending_tx_finish_0</source_block_id><sink_block_id>amsdu_frame_out</sink_block_id><source_key>amsdu_frame_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_pending_tx_finish_0</source_block_id><sink_block_id>beacon_frame_out</sink_block_id><source_key>beacon_frame_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_pending_tx_finish_0</source_block_id><sink_block_id>cts_frame_out</sink_block_id><source_key>cts_frame_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_pending_tx_finish_0</source_block_id><sink_block_id>data_frame_out</sink_block_id><source_key>data_frame_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_pending_tx_finish_0</source_block_id><sink_block_id>rts_frame_out</sink_block_id><source_key>rts_frame_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_pending_tx_finish_0</source_block_id><sink_block_id>rx_control_out</sink_block_id><source_key>rx_control_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_pending_tx_finish_0</source_block_id><sink_block_id>unknown_frame_out</sink_block_id><source_key>unknown_frame_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_direction_mapper_0</sink_block_id><source_key>trigger_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_t_control_tx_cc_0</source_block_id><sink_block_id>direction_out</sink_block_id><source_key>direction_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_t_control_tx_cc_0</source_block_id><sink_block_id>inets_pending_tx_finish_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_t_control_tx_cc_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inets_t_control_tx_cc_0</source_block_id><sink_block_id>sweep_finished</sink_block_id><source_key>sweep_finished</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inets_t_control_tx_cc_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>inets_t_control_tx_cc_0_1</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>inets_t_control_tx_cc_0_2</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>inets_decouple_frame_info_0</sink_block_id><source_key>out</source_key><sink_key>frame_cluster_in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>inets_direction_mapper_0</sink_block_id><source_key>out</source_key><sink_key>destination_address_check_in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>inets_pending_tx_finish_0</sink_block_id><source_key>out</source_key><sink_key>tx_frame_info_in</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pad_source_0_1</source_block_id><sink_block_id>inets_direction_mapper_0</sink_block_id><source_key>out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>pad_source_0_1_0</source_block_id><sink_block_id>inets_direction_mapper_0</sink_block_id><source_key>out</source_key><sink_key>movement_tracker_in</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

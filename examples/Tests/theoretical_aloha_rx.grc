<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>theoretical_aloha_rx</value></param>
<param><key>author</key><value>PWA</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>theoretical_aloha_rx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>range_mu</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_mu</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>BB Derotation Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_rx_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Rx Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_center_frequency</value></param>
<param><key>value</key><value>3.76e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeout_duration_ms</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_center_frequency</value></param>
<param><key>value</key><value>3.76e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr0=10.0.0.18"</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_2</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>my_address</key><value>source_address</value></param>
<param><key>output_payload_pmt</key><value>0</value></param>
<param><key>show_not_pass</key><value>0</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>4</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"destined"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>counter_id</key><value>5</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"not_destined"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>2</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"rx_mac_fr"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_2</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"rx_phy_pkt"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_2_0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>1</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"RSS"</value></param>
<param><key>record_on</key><value>1</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_1</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>3</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"bad_fr"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_1_0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>counter_id</key><value>11</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"payload"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_frame_analysis</key>
<param><key>id</key><value>inets_frame_analysis_0</value></param>
<param><key>apply_self_address_check</key><value>1</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_frame_check</key>
<param><key>id</key><value>inets_frame_check_0</value></param>
<param><key>block_id</key><value>9</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_bad_frame</key><value>0</value></param>
<param><key>output_payload_pmt</key><value>0</value></param>
</block>
<block>
<key>inets_receiving</key>
<param><key>id</key><value>inets_receiving_0</value></param>
<param><key>block_id</key><value>21</value></param>
<param><key>center_frequency</key><value>rx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset_rf</key><value>1</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>output_rss</key><value>0</value></param>
<param><key>output_rx_switch</key><value>1</value></param>
<param><key>output_snr</key><value>0</value></param>
<param><key>output_rx_frame</key><value>0</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>30</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<connection><source_block_id>inets_address_check_2</source_block_id><sink_block_id>inets_counter_0_0</sink_block_id><source_key>address_check_fail_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_address_check_2</source_block_id><sink_block_id>inets_counter_0</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0</source_block_id><sink_block_id>inets_counter_0_0_1</sink_block_id><source_key>frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0</source_block_id><sink_block_id>inets_frame_check_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_counter_0_1</sink_block_id><source_key>bad_frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_address_check_2</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_counter_0_1_0</sink_block_id><source_key>payload_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_counter_0_0_2</sink_block_id><source_key>rx_frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_frame_analysis_0</sink_block_id><source_key>rx_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rx_power_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>inets_counter_0_0_2_0</sink_block_id><source_key>rx_power_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_receiving_0</source_block_id><sink_block_id>blocks_message_debug_0_1</sink_block_id><source_key>snr_out</source_key><sink_key>print</sink_key></connection>
</flow_graph>

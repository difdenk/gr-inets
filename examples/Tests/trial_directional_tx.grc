<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_threshold</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>destination_address</value></param>
<param><key>value</key><value>99</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>diff_preamble_128</value></param>
<param><key>value</key><value>[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mu</value></param>
<param><key>value</key><value>range_mu</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_mu</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>BB Derotation Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_center_frequency</value></param>
<param><key>value</key><value>3.76e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_address</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>system_time_granularity_us</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeout_duration_ms</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_center_frequency</value></param>
<param><key>value</key><value>3.76e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_device_address</value></param>
<param><key>value</key><value>"addr0=192.168.10.2, addr1=192.168.10.3"</value></param>
</block>
<block>
<key>directional_sending</key>
<param><key>id</key><value>directional_sending_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>center_frequency</key><value>tx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>record_on</key><value>2</value></param>
<param><key>interframe_interval_s</key><value>0</value></param>
<param><key>file_name_extension_pending</key><value>"Tfr"</value></param>
<param><key>file_name_extension_t_control</key><value>"t1TXs"</value></param>
<param><key>name_with_timestamp</key><value>1</value></param>
<param><key>t_pretx_interval_s</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>ack_frame</key><value>0</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>beacon_frame</key><value>0</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
<param><key>rx_control</key><value>0</value></param>
<param><key>unknown_frame</key><value>1</value></param>
<param><key>sweep_mode</key><value>sweep_mode</value></param>
<param><key>tx_gain</key><value>tx_gain</value></param>
<param><key>phase</key><value>phase</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import gnuradio</value></param>
</block>
<block>
<key>inets_address_check</key>
<param><key>id</key><value>inets_address_check_2</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>my_address</key><value>source_address</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
<param><key>show_not_pass</key><value>0</value></param>
</block>
<block>
<key>inets_backoff</key>
<param><key>id</key><value>inets_backoff_0</value></param>
<param><key>apply_cs</key><value>1</value></param>
<param><key>backoff_time_unit_ms</key><value>10</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>virtual_cs</key><value>1</value></param>
<param><key>max_backoff_ms</key><value>400</value></param>
<param><key>min_backoff_ms</key><value>100</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>cs_threshold</key><value>0.005</value></param>
<param><key>backoff_type</key><value>3</value></param>
</block>
<block>
<key>inets_backoff</key>
<param><key>id</key><value>inets_backoff_0_0</value></param>
<param><key>apply_cs</key><value>1</value></param>
<param><key>backoff_time_unit_ms</key><value>10</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>virtual_cs</key><value>1</value></param>
<param><key>max_backoff_ms</key><value>400</value></param>
<param><key>min_backoff_ms</key><value>100</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>cs_threshold</key><value>0.005</value></param>
<param><key>backoff_type</key><value>1</value></param>
</block>
<block>
<key>inets_carrier_sensing</key>
<param><key>id</key><value>inets_carrier_sensing_0</value></param>
<param><key>block_id</key><value>11</value></param>
<param><key>rx_sensitivity_dB</key><value>10</value></param>
<param><key>nf_initial_n</key><value>100</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>cs_duration</key><value>100</value></param>
<param><key>cs_mode</key><value>1</value></param>
<param><key>show_fail</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>show_stop</key><value>0</value></param>
<param><key>system_time_granularity_us</key><value>system_time_granularity_us</value></param>
<param><key>cs_threshold</key><value>0.005</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>4</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"ack_sent"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>4</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"data_sent"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>4</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"data_received"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>4</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"ack_received"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>4</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"failed_frame"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1_0_0</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>4</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"extra_sent_frame"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_1_1</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>4</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"beacon_reply_received"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_counter</key>
<param><key>id</key><value>inets_counter_0_0_2</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>show_id</key><value>0</value></param>
<param><key>counter_id</key><value>4</value></param>
<param><key>interval_mode</key><value>1</value></param>
<param><key>counter_name</key><value>"beacon_sent"</value></param>
<param><key>record_on</key><value>0</value></param>
<param><key>record_path</key><value>"/home/inets/source/gr-inets/results/"</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>name_with_stamp</key><value>1</value></param>
</block>
<block>
<key>inets_direction_finder</key>
<param><key>id</key><value>inets_direction_finder_0</value></param>
<param><key>destination_address</key><value>3</value></param>
<param><key>develop_mode</key><value>1</value></param>
<param><key>timeout_value</key><value>1000</value></param>
<param><key>update_interval</key><value>20</value></param>
</block>
<block>
<key>inets_dummy_source</key>
<param><key>id</key><value>inets_dummy_source_0</value></param>
<param><key>block_id</key><value>23</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>packet_rate</key><value>1</value></param>
<param><key>payload_length</key><value>200</value></param>
<param><key>show</key><value>1</value></param>
<param><key>source_type</key><value>3</value></param>
</block>
<block>
<key>inets_frame_analysis</key>
<param><key>id</key><value>inets_frame_analysis_0</value></param>
<param><key>apply_self_address_check</key><value>1</value></param>
<param><key>block_id</key><value>7</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>my_address</key><value>source_address</value></param>
</block>
<block>
<key>inets_frame_buffer</key>
<param><key>id</key><value>inets_frame_buffer_0</value></param>
<param><key>auto_dequeue_first</key><value>1</value></param>
<param><key>auto_dequeue_full</key><value>1</value></param>
<param><key>block_id</key><value>16</value></param>
<param><key>buffer_size</key><value>500</value></param>
<param><key>keep_dequeue_state</key><value>1</value></param>
<param><key>dequeue</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>enqueue</key><value>0</value></param>
<param><key>flush</key><value>1</value></param>
<param><key>show_empty</key><value>1</value></param>
<param><key>show_full</key><value>1</value></param>
<param><key>indicate</key><value>1</value></param>
<param><key>output_empty</key><value>1</value></param>
<param><key>reset_size</key><value>1</value></param>
</block>
<block>
<key>inets_frame_check</key>
<param><key>id</key><value>inets_frame_check_0</value></param>
<param><key>block_id</key><value>9</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_bad_frame</key><value>0</value></param>
<param><key>output_payload_pmt</key><value>1</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0_0_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0_1</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_0_1_0</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_path</key>
<param><key>id</key><value>inets_frame_path_1</value></param>
<param><key>block_id</key><value>39</value></param>
<param><key>develop_mode</key><value>0</value></param>
</block>
<block>
<key>inets_frame_type_check</key>
<param><key>id</key><value>inets_frame_type_check_0</value></param>
<param><key>ack_frame</key><value>0</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>ampdu_subframe</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>amsdu_subframe</key><value>1</value></param>
<param><key>other_frame</key><value>0</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>block_id</key><value>25</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
</block>
<block>
<key>inets_frame_type_check</key>
<param><key>id</key><value>inets_frame_type_check_0_0</value></param>
<param><key>ack_frame</key><value>0</value></param>
<param><key>ampdu_frame</key><value>1</value></param>
<param><key>ampdu_subframe</key><value>1</value></param>
<param><key>amsdu_frame</key><value>1</value></param>
<param><key>amsdu_subframe</key><value>1</value></param>
<param><key>other_frame</key><value>1</value></param>
<param><key>beacon_frame</key><value>1</value></param>
<param><key>block_id</key><value>25</value></param>
<param><key>cts_frame</key><value>1</value></param>
<param><key>data_frame</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>rts_frame</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>angle_in_h</key><value>1</value></param>
<param><key>node_addresses_in_h</key><value>1</value></param>
<param><key>snr_in_h</key><value>1</value></param>
<param><key>frame_type</key><value>2</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>1</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_0_0</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>angle_in_h</key><value>1</value></param>
<param><key>node_addresses_in_h</key><value>0</value></param>
<param><key>snr_in_h</key><value>1</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>1</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>inets_framing</key>
<param><key>id</key><value>inets_framing_1</value></param>
<param><key>block_id</key><value>17</value></param>
<param><key>default_framing_setting</key><value>default</value></param>
<param><key>default_payload_length</key><value>300</value></param>
<param><key>destination_address</key><value>destination_address</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>angle_in_h</key><value>0</value></param>
<param><key>node_addresses_in_h</key><value>1</value></param>
<param><key>snr_in_h</key><value>1</value></param>
<param><key>frame_type</key><value>3</value></param>
<param><key>increase_index</key><value>1</value></param>
<param><key>frame_index</key><value>0</value></param>
<param><key>len_destination_address</key><value>1</value></param>
<param><key>len_frame_index</key><value>1</value></param>
<param><key>len_frame_type</key><value>1</value></param>
<param><key>len_num_transmission</key><value>1</value></param>
<param><key>len_payload_length</key><value>2</value></param>
<param><key>len_reserved_field_I</key><value>2</value></param>
<param><key>len_reserved_field_II</key><value>2</value></param>
<param><key>len_slot_time_beacon</key><value>2</value></param>
<param><key>len_source_address</key><value>1</value></param>
<param><key>node_list</key><value>[2, 3]</value></param>
<param><key>output_frame_pmt</key><value>1</value></param>
<param><key>reserved_field_I</key><value>318</value></param>
<param><key>reserved_field_II</key><value>524</value></param>
<param><key>reserved_field_ampdu</key><value>0</value></param>
<param><key>set_reserved_field</key><value>1</value></param>
<param><key>show_reset_index</key><value>1</value></param>
<param><key>slot_list_ms</key><value>[1000, 1000]</value></param>
<param><key>source_address</key><value>source_address</value></param>
<param><key>default_payload</key><value>0</value></param>
<param><key>internal_index</key><value>1</value></param>
</block>
<block>
<key>inets_general_timeout</key>
<param><key>id</key><value>inets_general_timeout_0</value></param>
<param><key>block_id</key><value>34</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>output_former</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>1000</value></param>
<param><key>timeout_duration_ms</key><value>3000</value></param>
<param><key>timeout_mode</key><value>1</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>200</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>1</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>1</value></param>
</block>
<block>
<key>inets_general_timer</key>
<param><key>id</key><value>inets_general_timer_0_0</value></param>
<param><key>block_id</key><value>5</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>duration_ms</key><value>150</value></param>
<param><key>address_check</key><value>1</value></param>
<param><key>disable_timer</key><value>1</value></param>
<param><key>resume_timer</key><value>1</value></param>
<param><key>suspend_timer</key><value>0</value></param>
<param><key>reserved_time_ms</key><value>0</value></param>
<param><key>reset_duration</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
<param><key>timer_type</key><value>1</value></param>
</block>
<block>
<key>inets_resend_check</key>
<param><key>id</key><value>inets_resend_check_0</value></param>
<param><key>block_id</key><value>24</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>max_resend</key><value>6</value></param>
</block>
<block>
<key>inets_run</key>
<param><key>id</key><value>inets_run_0</value></param>
<param><key>start_next_time_s</key><value>5</value></param>
<param><key>system_time_granularity_us</key><value>10</value></param>
</block>
<block>
<key>inets_timeout</key>
<param><key>id</key><value>inets_timeout_0</value></param>
<param><key>block_id</key><value>10</value></param>
<param><key>data_ack</key><value>0</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>llc_protocol</key><value>0</value></param>
<param><key>rts_cts</key><value>1</value></param>
<param><key>system_time_granularity_us</key><value>1000</value></param>
<param><key>timeout_duration_ms</key><value>300</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phase</value></param>
<param><key>label</key><value>phase</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>receiving_directional</key>
<param><key>id</key><value>receiving_directional_0</value></param>
<param><key>block_id</key><value>21</value></param>
<param><key>center_frequency</key><value>rx_center_frequency</value></param>
<param><key>develop_mode</key><value>0</value></param>
<param><key>reset_rf</key><value>0</value></param>
<param><key>reset</key><value>1</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>output_rss</key><value>0</value></param>
<param><key>output_rx_switch</key><value>0</value></param>
<param><key>output_snr</key><value>0</value></param>
<param><key>output_rx_frame</key><value>0</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>30</value></param>
<param><key>constellation</key><value>gnuradio.digital.constellation_qpsk().base()</value></param>
<param><key>matched_filter_coeff</key><value>rrc</value></param>
<param><key>preamble</key><value>diff_preamble_128</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>usrp_device_address</key><value>usrp_device_address</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sweep_mode</value></param>
<param><key>label</key><value>sweep_mode</value></param>
<param><key>value</key><value>0.2</value></param>
</block>
<connection><source_block_id>directional_sending_0</source_block_id><sink_block_id>inets_counter_0_0</sink_block_id><source_key>ack_frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>directional_sending_0</source_block_id><sink_block_id>inets_counter_0_0_2</sink_block_id><source_key>beacon_frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>directional_sending_0</source_block_id><sink_block_id>inets_counter_0_0_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>directional_sending_0</source_block_id><sink_block_id>inets_timeout_0</sink_block_id><source_key>data_frame_out</source_key><sink_key>data_frame_info_in</sink_key></connection>
<connection><source_block_id>directional_sending_0</source_block_id><sink_block_id>inets_frame_path_0_1</sink_block_id><source_key>direction_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>directional_sending_0</source_block_id><sink_block_id>inets_frame_path_0</sink_block_id><source_key>rx_control_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>directional_sending_0</source_block_id><sink_block_id>inets_direction_finder_0</sink_block_id><source_key>sweep_finished</source_key><sink_key>sweep_done_in</sink_key></connection>
<connection><source_block_id>inets_address_check_2</source_block_id><sink_block_id>inets_frame_type_check_0</sink_block_id><source_key>address_check_pass_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_backoff_0</source_block_id><sink_block_id>inets_frame_path_0_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_backoff_0_0</source_block_id><sink_block_id>inets_resend_check_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>inets_frame_path_0_1_0</sink_block_id><source_key>cmd_fail_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_carrier_sensing_0</source_block_id><sink_block_id>receiving_directional_0</sink_block_id><source_key>cmd_pass_out</source_key><sink_key>rx_switch_in</sink_key></connection>
<connection><source_block_id>inets_direction_finder_0</source_block_id><sink_block_id>directional_sending_0</sink_block_id><source_key>best_direction_out</source_key><sink_key>direction_in</sink_key></connection>
<connection><source_block_id>inets_direction_finder_0</source_block_id><sink_block_id>inets_frame_path_0_0_0</sink_block_id><source_key>best_direction_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_direction_finder_0</source_block_id><sink_block_id>inets_framing_0_0</sink_block_id><source_key>best_direction_out</source_key><sink_key>node_addresses_in</sink_key></connection>
<connection><source_block_id>inets_direction_finder_0</source_block_id><sink_block_id>inets_general_timer_0_0</sink_block_id><source_key>best_direction_out</source_key><sink_key>suspend_timer_in</sink_key></connection>
<connection><source_block_id>inets_direction_finder_0</source_block_id><sink_block_id>directional_sending_0</sink_block_id><source_key>movement_tracker_out</source_key><sink_key>movement_tracker_in</sink_key></connection>
<connection><source_block_id>inets_dummy_source_0</source_block_id><sink_block_id>inets_framing_0_0</sink_block_id><source_key>output</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_analysis_0</source_block_id><sink_block_id>inets_frame_check_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_buffer_0</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>dequeue_element</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>inets_frame_check_0</source_block_id><sink_block_id>inets_address_check_2</sink_block_id><source_key>good_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_0</source_block_id><sink_block_id>receiving_directional_0</sink_block_id><source_key>frame_out</source_key><sink_key>rx_switch_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_0_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>frame_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_frame_path_0_0_0</source_block_id><sink_block_id>inets_general_timer_0</sink_block_id><source_key>frame_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_0_1</source_block_id><sink_block_id>inets_framing_1</sink_block_id><source_key>frame_out</source_key><sink_key>angle_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_0_1_0</source_block_id><sink_block_id>inets_backoff_0_0</sink_block_id><source_key>frame_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_path_1</source_block_id><sink_block_id>inets_general_timeout_0</sink_block_id><source_key>frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_counter_0_0_1</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_direction_finder_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>ack_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_general_timeout_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_timeout_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>ack_frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_counter_0_0_1_1</sink_block_id><source_key>beacon_reply_frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_direction_finder_0</sink_block_id><source_key>beacon_reply_frame_info_out</source_key><sink_key>beacon_reply_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_counter_0_0_0_0</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0</source_block_id><sink_block_id>inets_framing_0</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0</source_block_id><sink_block_id>inets_backoff_0</sink_block_id><source_key>ack_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_frame_type_check_0_0</source_block_id><sink_block_id>inets_backoff_0_0</sink_block_id><source_key>data_frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>inets_framing_0</source_block_id><sink_block_id>receiving_directional_0</sink_block_id><source_key>frame_out</source_key><sink_key>rx_switch_in</sink_key></connection>
<connection><source_block_id>inets_framing_0_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>frame_out</source_key><sink_key>enqueue</sink_key></connection>
<connection><source_block_id>inets_framing_1</source_block_id><sink_block_id>receiving_directional_0</sink_block_id><source_key>frame_out</source_key><sink_key>rx_switch_in</sink_key></connection>
<connection><source_block_id>inets_general_timeout_0</source_block_id><sink_block_id>inets_direction_finder_0</sink_block_id><source_key>expired_frame_out</source_key><sink_key>timeout_in</sink_key></connection>
<connection><source_block_id>inets_general_timeout_0</source_block_id><sink_block_id>inets_frame_path_1</sink_block_id><source_key>expired_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>inets_general_timer_0</source_block_id><sink_block_id>inets_dummy_source_0</sink_block_id><source_key>expire_signal_out</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>inets_general_timer_0_0</source_block_id><sink_block_id>inets_framing_1</sink_block_id><source_key>expire_signal_out</source_key><sink_key>data_in</sink_key></connection>
<connection><source_block_id>inets_resend_check_0</source_block_id><sink_block_id>inets_counter_0_0_1_0</sink_block_id><source_key>resend_check_fail_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_resend_check_0</source_block_id><sink_block_id>inets_frame_buffer_0</sink_block_id><source_key>resend_check_fail_out</source_key><sink_key>dequeue</sink_key></connection>
<connection><source_block_id>inets_resend_check_0</source_block_id><sink_block_id>inets_counter_0_0_1_0_0</sink_block_id><source_key>resend_check_pass_out</source_key><sink_key>message_in</sink_key></connection>
<connection><source_block_id>inets_resend_check_0</source_block_id><sink_block_id>receiving_directional_0</sink_block_id><source_key>resend_check_pass_out</source_key><sink_key>rx_switch_in</sink_key></connection>
<connection><source_block_id>inets_run_0</source_block_id><sink_block_id>inets_general_timer_0_0</sink_block_id><source_key>trigger_out</source_key><sink_key>active_in</sink_key></connection>
<connection><source_block_id>inets_timeout_0</source_block_id><sink_block_id>inets_frame_type_check_0_0</sink_block_id><source_key>frame_info_out</source_key><sink_key>frame_info_in</sink_key></connection>
<connection><source_block_id>receiving_directional_0</source_block_id><sink_block_id>inets_frame_analysis_0</sink_block_id><source_key>rx_frame_out</source_key><sink_key>frame_in</sink_key></connection>
<connection><source_block_id>receiving_directional_0</source_block_id><sink_block_id>inets_carrier_sensing_0</sink_block_id><source_key>rx_power_out</source_key><sink_key>power_in</sink_key></connection>
<connection><source_block_id>receiving_directional_0</source_block_id><sink_block_id>directional_sending_0</sink_block_id><source_key>rx_switch_out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
